# IAR project subscriber.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1769 NXP LPC1769
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NBOOTLOADER
  ICCARM.CCDiagSuppress: Pe550, Pe186, Pe188, Pe068, Pa082, Pa039, Pa084, Pa050,
  ICCARM.CCIncludePath2: Application; include\cmsis_drivers; include\Net; include\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: subscriber.hex
  ILINK.IlinkOutputFile: subscriber.out
  ILINK.IlinkIcfFile: ldscript_irom_iar.ld
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; BOOTLOADER
  OBJCOPY.OOCOutputFile: subscriber_release.bin
  ILINK.IlinkOutputFile: subscriber_release.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkIcfFile: subscriber_realease.ld
  group Application
    Application/: fsm_deteccion.c iButtons.c main.c radar.c udpserver.c zonescan.c
  group Autoprotect
    Autoprotect/: autoprotect.c
  group BSP
    BSP/: cpu_bsp.c startup_LPC17xx.s system_LPC17xx.c
  group Connection
    Connection/: protocols.c rabbit.c
  group Console
    Console/: console.c
  group DataFlash
    DataFlash/: DataFlash.c
  group Lan485
    Lan485/: lan485.c
  group LogEventos
    LogEventos/: log_event.c
  group LPC1769_CMSIS_Drivers
    LPC1769_CMSIS_Driver/: debug_frmwrk.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c
  group mem_i2c
    mem_i2c/: mem_i2c.c
  group Micrium/uC_CPU
    Micrium/uC_CPU/: cpu_a.asm cpu_c.c cpu_core.c
  group Micrium/uC_CSP
    Micrium/uC_CSP/: csp_dma.c csp_gpio.c csp_int.c csp_pm.c
  group Micrium/uC_LIB
    Micrium/uC_LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group Micrium/uC_OS_III
    Micrium/uC_OS_III/: os_cfg_app.c os_core.c os_cpu_a.s os_cpu_c.c os_csp.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group Micrium/uC_TCPIP/BSD_Socket_Layer
    Micrium/uC_TCPIP/BSD_Socket_Layer/: net_bsd.c net_sock.c
  group Micrium/uC_TCPIP/IF_Layer
    Micrium/uC_TCPIP/IF_Layer/: net_if.c net_if_pkt.c
  group Micrium/uC_TCPIP/NIC_Layer
    Micrium/uC_TCPIP/NIC_Layer/: net_bsp.c net_nic.c net_phy.c
  group Micrium/uC_TCPIP/TCPIP_Layer
    Micrium/uC_TCPIP/TCPIP_Layer/: net.c net_arp.c net_ascii.c net_buf.c net_conn.c net_ctr.c net_dbg.c net_err.c net_icmp.c net_ip.c net_os.c net_stat.c net_tcp.c net_tmr.c net_udp.c net_util.c
  group Modem
    Modem/: modem.c
  group Serial
    Serial/: serial.c
  group Timestamp
    Timestamp/: time.c
  group Utils
    Utils/: utils.c
